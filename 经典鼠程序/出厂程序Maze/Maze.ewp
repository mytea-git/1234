# IAR project Maze.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8n.h
  General.OGChipSelectEditMenu: LM3S615 Luminary LM3S615
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\Luminary
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk_LM3.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group lib
    $EW_DIR$/arm/lib/Luminary/: driverlib.r79
  group src
    src/: drive_7289.c maze.c Mouse_Drive.c astar_core.c path_optimizer.c path_cache.c motion_params.c
  group startup
    src/: startup.c
